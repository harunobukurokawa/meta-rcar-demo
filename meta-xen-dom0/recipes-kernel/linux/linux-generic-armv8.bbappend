FILESEXTRAPATHS:prepend := "${THISDIR}/${PN}:"

SRC_URI = "\
    file://netfront.cfg \
"
